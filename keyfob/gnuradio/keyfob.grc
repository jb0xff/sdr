options:
  parameters:
    generate_options: qt_gui
    id: lesson1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/star/Documents/gnuradio-files/mitsubishi_keyfob_gnu_file
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/star/Documents/gnuradio-files/mitsubishi_keyfob_gnu_file
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '.1'
    init: '0'
    low: '.05'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '.1'
    init: '0'
    low: '-.15'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pickle
      import datetime


      def bitstring_to_bytes(s):
          v = int(s, 2)
          b = bytearray()
          while v:
              b.append(v & 0xff)
              v >>= 8
          return bytes(b[::-1])


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, preamble_bits=1, edge_offset=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='KeyFob Decoder',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.preamble_bits = preamble_bits
              self.edge_offset = edge_offset
              self.total_data_points = 0
              self.data_points_threshold = []
              self.data_points_signal = np.array([])
              self.state = 1
              self.frame_start = None
              self.frame_stop = None
              self.keys = [
                      "000000000000000001110000000000000000000000000000000011101111",
                      "000000000000000000010000000000000000000000000000000010100010",
                      "000000000000000000110000000000000000000000000000000010011001",
                      "000000000000000000010000000000000000000000000000000010100010",
                      "000000000000000011110000000000000000000000000000000000000011",
                      "000000000000000000010000000000000000000000000000000010100010",
                      "000000000000000000110000000000000000000000000000000010011001",
                      "000000000000000000010000000000000000000000000000000010100010",
                          ]

          def work(self, input_items, output_items):
              input_threshold = np.array(input_items[0])
              input_signal = np.array(input_items[1])
              if np.any(input_threshold > 0.5):
                  print(len(input_signal))
                  # self.total_data_points += len(input_signal)
                  # # print(f"input signal len({len(input_signal)}), total {self.total_data_points})")
                  # if self.state == 1:
                  #     leading_edge = (input_threshold[:-1] - input_threshold[1:]) < -0.5
                  #     if len(np.where(leading_edge)) > 1:
                  #         print(f"multi leading edge {len(leading_edge)}")
                  #     if np.any(leading_edge == True):
                  #         #Find the first place that a negative is located.
                  #         location = np.where(leading_edge)[0][0]
                  #         #Store the start location.
                  #         self.frame_start = location + 0 #delay start to eliminate leading jitter.
                  #         #When edge is found start looking for the trailing edge
                  #         self.state = 2
                  #         #Store the data because it will span several frames.
                  #         self.data_points_signal = np.append(self.data_points_signal, input_signal)
                  #
                  # if self.state == 2:
                  #     self.data_points_signal = np.append(self.data_points_signal, input_signal)
                  #     # Calculate sample 1 minus sample 2. If edge goes negative then the answer is positive.
                  #     trailing_edge = (input_threshold[:-1] - input_threshold[1:]) > 0.5
                  #     if len(np.where(trailing_edge)) > 1:
                  #         print("multi trailing edge {len(trailing_edge)}")
                  #     # self.total_data_points += len(input_threshold)
                  #     # self.data_points_threshold.append(input_threshold)
                  #     # if self.total_data_points > 700000: # depends on the sample rate in gnuradio
                  #     #     print(f"Threshold!, points collected: {self.total_data_points}")
                  #     #     self.total_data_points = 0
                  #     #     for data_point in self.data_points_threshold:
                  #     #         if np.any(data_point > 0.5):
                  #     #             if np.any((data_point[:-1] - data_point[1:]) < -0.5):
                  #     #                 leading_edge = (data_point[:-1] - data_point[1:]) < -0.5
                  #     #                 location = np.where(leading_edge)[0][0]
                  #     #                 print(f"leading edge at:{index},{int(location + 1)}")
                  #         # with open(f'{datetime.datetime.now().strftime("%Y%m%d_%H%m%S")}_data_points.pkl', 'ab') as file:
                  #         #     pickle.dump(self.data_points_threshold, file, pickle.HIGHEST_PROTOCOL)
                  #         # self.data_points_threshold = []
                  #
                  #     # Check if any go positive.
                  #     if np.any(trailing_edge == True):
                  #         # Find the first place a positive is located.
                  #         location = np.where(trailing_edge)[0][0]
                  #         # Store the relative stop location as it is in the whole data set not just the current frame.
                  #         self.frame_stop = (len(self.data_points_signal) - int(len(input_signal))) + location
                  #         # debug
                  #         # print 'trailing edge location ', stop
                  #         # print 'stop minus start', (stop - start)
                  #         self.state = 3
                  #
                  # if self.state == 3:
                  #     positive_edges = []
                  #     negative_edges = []
                  #     state = 0
                  #     data = self.data_points_signal
                  #     for index, d in enumerate(data):
                  #         if state == 0 and d == 1:
                  #             positive_edges.append(index)
                  #             state = 1
                  #         if state == 1 and d == 0:
                  #             negative_edges.append(index)
                  #             state = 0
                  #     durations = []
                  #     for index, edge in enumerate(positive_edges):
                  #         diff = negative_edges[index] - edge
                  #         durations.append(diff)
                  #     signal1 = []
                  #     signal_started = False
                  #     signal_end = None
                  #     for index, d in enumerate(durations):
                  #         if d > 1000 or signal_started:
                  #             signal_started = True
                  #             if 1000 < d < 1500:
                  #                 signal1.append(1)
                  #             if d < 1000:
                  #                 signal1.append(0)
                  #             if d > 1500:
                  #                 signal_end = index + 1  # save where signal has ended in the data
                  #                 signal_started = False
                  #                 break
                  #     signal2 = []
                  #     for index, d in enumerate(durations[signal_end:]):
                  #         if d > 1000 or signal_started:
                  #             signal_started = True
                  #             if 1000 < d < 1500:
                  #                 signal2.append(1)
                  #             if d < 1000:
                  #                 signal2.append(0)
                  #             if d > 1500:
                  #                 break
                  #     print(f"Singal_1: {bitstring_to_bytes(''.join(str(d) for d in signal1))}, bitstream {''.join(str(d) for d in signal1)}")
                  #     # print(f"Singal_2: {bitstring_to_bytes(''.join(str(d) for d in signal2))}, bitstream {''.join(str(d) for d in signal2)}")
                  #     signal = ''.join(str(d) for d in signal1)
                  #     for key in self.keys:
                  #         next_signal = []
                  #         for index,s in enumerate(signal):
                  #             next_signal.append(int(s) ^ int(key[index]))
                  #         print(''.join(str(d) for d in next_signal))
                  #     self.total_data_points = 0
                  #     self.data_points_threshold = []
                  #     self.data_points_signal = np.array([])
                  #     self.state = 1
                  #     self.frame_start = None
                  #     self.frame_stop = None
              return len(input_items[0])
    edge_offset: '1'
    preamble_bits: '1'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: '[-0.00016243761638179421,-0.00016558055358473212,-0.0001686043688096106,-0.00017150805797427893,-0.0001742900349199772,-0.00017694786947686225,-0.00017947843298316002,-0.0001818778837332502,-0.00018414149235468358,-0.0001862638018792495,-0.0001882385549833998,-0.0001900586939882487,-0.00019171628809999675,-0.00019320272258482873,-0.00019450850959401578,-0.00019562343368306756,-0.00019653643539641052,-0.00019723584409803152,-0.00019770914514083415,-0.00019794327090494335,-0.00019792435341514647,-0.00019763804448302835,-0.00019706934108398855,-0.0001962027745321393,-0.00019502232316881418,-0.0001935116306412965,-0.00019165391859132797,-0.00018943210307043046,-0.00018682889640331268,-0.00018382679263595492,-0.0001804082130547613,-0.00017655554984230548,-0.0001722512097330764,-0.00016747775953263044,-0.00016221796977333724,-0.00015645487292204052,-0.0001501719088992104,-0.00014335296873468906,-0.00013598246732726693,-0.00012804550351575017,-0.00011952789645874873,-0.00011041626567021012,-0.0001006981692626141,-9.036214032676071e-05,-7.939784700283781e-05,-6.779612158425152e-05,-5.554909148486331e-05,-4.265023744665086e-05,-2.909450813604053e-05,-1.4878390174999367e-05,1.4229635233519693e-19,1.554083610244561e-05,3.174250741722062e-05,4.860152330365963e-05,6.611246499232948e-05,8.426790736848488e-05,0.00010305832984158769,0.0001224720908794552,0.00014249533705879003,0.0001631119812373072,0.0001843036152422428,0.00020604950259439647,0.0002283265203004703,0.00025110915885306895,0.00027436940581537783,0.00029807683313265443,0.0003221985243726522,0.0003466990601737052,0.00037154057645238936,0.00039668273529969156,0.00042208266677334905,0.0004476950562093407,0.0004734722606372088,0.0004993641632609069,0.0005253182607702911,0.0005512798670679331,0.0005771919386461377,0.0006029954529367387,0.0006286289426498115,0.0006540293106809258,0.0006791310734115541,0.0007038672920316458,0.0007281691650860012,0.0007519660866819322,0.0007751862285658717,0.0007977559580467641,0.0008196007693186402,0.0008406448177993298,0.0008608114439994097,0.0008800228242762387,0.0008982007275335491,0.0009152663988061249,0.000931140617467463,0.0009457439882680774,0.0009589973487891257,0.0009708214201964438,0.0009811373893171549,0.000989867141470313,0.0009969334350898862,0.0010022593196481466,0.0010057700565084815,0.0010073913726955652,0.0010070513235405087,0.0010046788956969976,0.001000206102617085,0.0009935664711520076,0.0009846960892900825,0.0009735338971950114,0.00096002162899822,0.0009441041038371623,0.0009257293422706425,0.0009048490319401026,0.0008814185275696218,0.0008553969673812389,0.0008267477969639003,0.0007954387692734599,0.000761442061048001,0.000724734622053802,0.0006852982915006578,0.000643119914457202,0.000598191749304533,0.0005505112349055707,0.0005000816308893263,0.0004469116684049368,0.0003910161030944437,0.00033241568598896265,0.0002711371926125139,0.00020721375767607242,0.0001406847295584157,7.159602682804689e-05,-4.542498005998868e-19,-7.404436473734677e-05,-0.00015047141641844064,-0.00022920880292076617,-0.0003101773909293115,-0.0003932913823518902,-0.0004784580087289214,-0.0005655778222717345,-0.000654544506687671,-0.0007452451973222196,-0.0008375601028092206,-0.000931362621486187,-0.0010265200398862362,-0.0011228928342461586,-0.0012203347869217396,-0.001318693975917995,-0.001417811494320631,-0.0015175234293565154,-0.0016176586505025625,-0.0017180412542074919,-0.0018184896325692534,-0.0019188161240890622,-0.002018829109147191,-0.002118330681696534,-0.002217118861153722,-0.002314987126737833,-0.0024117249995470047,-0.0025071173440665007,-0.0026009457651525736,-0.002692988608032465,-0.002783020492643118,-0.002870814176276326,-0.0029561391565948725,-0.003038763301447034,-0.003118452150374651,-0.0031949705444276333,-0.0032680814620107412,-0.003337548114359379,-0.003403132315725088,-0.003464596578851342,-0.0035217038821429014,-0.0035742181353271008,-0.0036219037137925625,-0.0036645270884037018,-0.0037018575239926577,-0.0037336654495447874,-0.0037597252521663904,-0.0037798138801008463,-0.0037937117740511894,-0.0038012047298252583,-0.003802082035690546,-0.0037961374036967754,-0.003783171297982335,-0.0037629888392984867,-0.0037354021333158016,-0.003700228873640299,-0.003657294437289238,-0.0036064311861991882,-0.0035474796313792467,-0.00348028726875782,-0.003404711140319705,-0.0033206166699528694,-0.0032278785947710276,-0.003126380732282996,-0.003016016911715269,-0.0028966909740120173,-0.0027683174703270197,-0.0026308209635317326,-0.0024841378908604383,-0.0023282149340957403,-0.002163011347874999,-0.0019884968642145395,-0.001804653787985444,-0.001611476531252265,-0.001408971264027059,-0.001197157078422606,-0.0009760655811987817,-0.0007457407773472369,-0.0005062395357526839,-0.0002576317056082189,8.1740881778420905e-19,0.0002665599749889225,0.0005419395165517926,0.0008260168833658099,0.0011186576448380947,0.0014197139535099268,0.0017290255054831505,0.0020464190747588873,0.0023717086296528578,0.002704695798456669,0.003045169170945883,0.003392905695363879,0.003747669979929924,0.004109214525669813,0.004477281589061022,0.004851599223911762,0.005231886636465788,0.0056178513914346695,0.00600919034332037,0.0064055901020765305,0.006806728430092335,0.00721227191388607,0.007621878292411566,0.008035196922719479,0.008451870642602444,0.008871530182659626,0.009293802082538605,0.009718302637338638,0.010144648142158985,0.010572440922260284,0.011001280508935452,0.011430763639509678,0.011860480532050133,0.012290016748011112,0.012718955054879189,0.01314687542617321,0.013573355972766876,0.013997972011566162,0.014420296996831894,0.014839903451502323,0.015256367623806,0.015669258311390877,0.016078155487775803,0.016482634469866753,0.016882270574569702,0.017276648432016373,0.017665350809693336,0.018047966063022614,0.01842408813536167,0.018793314695358276,0.019155248999595642,0.01950949989259243,0.019855687394738197,0.02019342966377735,0.02052236534655094,0.02084212936460972,0.021152373403310776,0.021452754735946655,0.021742939949035645,0.022022608667612076,0.022291451692581177,0.02254916913807392,0.02279547043144703,0.023030081763863564,0.023252742365002632,0.02346320077776909,0.023661216720938683,0.023846570402383804,0.02401905134320259,0.024178465828299522,0.024324631318449974,0.024457382038235664,0.024576568976044655,0.024682054296135902,0.024773718789219856,0.024851461872458458,0.024915188550949097,0.02496482990682125,0.025000328198075294,0.025021642446517944,0.02502875030040741,0.025021642446517944,0.025000328198075294,0.02496482990682125,0.024915188550949097,0.024851461872458458,0.024773718789219856,0.024682054296135902,0.024576568976044655,0.024457382038235664,0.024324631318449974,0.024178465828299522,0.02401905134320259,0.023846570402383804,0.023661216720938683,0.02346320077776909,0.023252742365002632,0.023030081763863564,0.02279547043144703,0.02254916913807392,0.022291451692581177,0.022022608667612076,0.021742939949035645,0.021452754735946655,0.021152373403310776,0.02084212936460972,0.02052236534655094,0.02019342966377735,0.019855687394738197,0.01950949989259243,0.019155248999595642,0.018793314695358276,0.01842408813536167,0.018047966063022614,0.017665350809693336,0.017276648432016373,0.016882270574569702,0.016482634469866753,0.016078155487775803,0.015669258311390877,0.015256367623806,0.014839903451502323,0.014420296996831894,0.013997972011566162,0.013573355972766876,0.01314687542617321,0.012718955054879189,0.012290016748011112,0.011860480532050133,0.011430763639509678,0.011001280508935452,0.010572440922260284,0.010144648142158985,0.009718302637338638,0.009293802082538605,0.008871530182659626,0.008451870642602444,0.008035196922719479,0.007621878292411566,0.00721227191388607,0.006806728430092335,0.0064055901020765305,0.00600919034332037,0.0056178513914346695,0.005231886636465788,0.004851599223911762,0.004477281589061022,0.004109214525669813,0.003747669979929924,0.003392905695363879,0.003045169170945883,0.002704695798456669,0.0023717086296528578,0.0020464190747588873,0.0017290255054831505,0.0014197139535099268,0.0011186576448380947,0.0008260168833658099,0.0005419395165517926,0.0002665599749889225,8.1740881778420905e-19,-0.0002576317056082189,-0.0005062395357526839,-0.0007457407773472369,-0.0009760655811987817,-0.001197157078422606,-0.001408971264027059,-0.001611476531252265,-0.001804653787985444,-0.0019884968642145395,-0.002163011347874999,-0.0023282149340957403,-0.0024841378908604383,-0.0026308209635317326,-0.0027683174703270197,-0.0028966909740120173,-0.003016016911715269,-0.003126380732282996,-0.0032278785947710276,-0.0033206166699528694,-0.003404711140319705,-0.00348028726875782,-0.0035474796313792467,-0.0036064311861991882,-0.003657294437289238,-0.003700228873640299,-0.0037354021333158016,-0.0037629888392984867,-0.003783171297982335,-0.0037961374036967754,-0.003802082035690546,-0.0038012047298252583,-0.0037937117740511894,-0.0037798138801008463,-0.0037597252521663904,-0.0037336654495447874,-0.0037018575239926577,-0.0036645270884037018,-0.0036219037137925625,-0.0035742181353271008,-0.0035217038821429014,-0.003464596578851342,-0.003403132315725088,-0.003337548114359379,-0.0032680814620107412,-0.0031949705444276333,-0.003118452150374651,-0.003038763301447034,-0.0029561391565948725,-0.002870814176276326,-0.002783020492643118,-0.002692988608032465,-0.0026009457651525736,-0.0025071173440665007,-0.0024117249995470047,-0.002314987126737833,-0.002217118861153722,-0.002118330681696534,-0.002018829109147191,-0.0019188161240890622,-0.0018184896325692534,-0.0017180412542074919,-0.0016176586505025625,-0.0015175234293565154,-0.001417811494320631,-0.001318693975917995,-0.0012203347869217396,-0.0011228928342461586,-0.0010265200398862362,-0.000931362621486187,-0.0008375601028092206,-0.0007452451973222196,-0.000654544506687671,-0.0005655778222717345,-0.0004784580087289214,-0.0003932913823518902,-0.0003101773909293115,-0.00022920880292076617,-0.00015047141641844064,-7.404436473734677e-05,-4.542498005998868e-19,7.159602682804689e-05,0.0001406847295584157,0.00020721375767607242,0.0002711371926125139,0.00033241568598896265,0.0003910161030944437,0.0004469116684049368,0.0005000816308893263,0.0005505112349055707,0.000598191749304533,0.000643119914457202,0.0006852982915006578,0.000724734622053802,0.000761442061048001,0.0007954387692734599,0.0008267477969639003,0.0008553969673812389,0.0008814185275696218,0.0009048490319401026,0.0009257293422706425,0.0009441041038371623,0.00096002162899822,0.0009735338971950114,0.0009846960892900825,0.0009935664711520076,0.001000206102617085,0.0010046788956969976,0.0010070513235405087,0.0010073913726955652,0.0010057700565084815,0.0010022593196481466,0.0009969334350898862,0.000989867141470313,0.0009811373893171549,0.0009708214201964438,0.0009589973487891257,0.0009457439882680774,0.000931140617467463,0.0009152663988061249,0.0008982007275335491,0.0008800228242762387,0.0008608114439994097,0.0008406448177993298,0.0008196007693186402,0.0007977559580467641,0.0007751862285658717,0.0007519660866819322,0.0007281691650860012,0.0007038672920316458,0.0006791310734115541,0.0006540293106809258,0.0006286289426498115,0.0006029954529367387,0.0005771919386461377,0.0005512798670679331,0.0005253182607702911,0.0004993641632609069,0.0004734722606372088,0.0004476950562093407,0.00042208266677334905,0.00039668273529969156,0.00037154057645238936,0.0003466990601737052,0.0003221985243726522,0.00029807683313265443,0.00027436940581537783,0.00025110915885306895,0.0002283265203004703,0.00020604950259439647,0.0001843036152422428,0.0001631119812373072,0.00014249533705879003,0.0001224720908794552,0.00010305832984158769,8.426790736848488e-05,6.611246499232948e-05,4.860152330365963e-05,3.174250741722062e-05,1.554083610244561e-05,1.4229635233519693e-19,-1.4878390174999367e-05,-2.909450813604053e-05,-4.265023744665086e-05,-5.554909148486331e-05,-6.779612158425152e-05,-7.939784700283781e-05,-9.036214032676071e-05,-0.0001006981692626141,-0.00011041626567021012,-0.00011952789645874873,-0.00012804550351575017,-0.00013598246732726693,-0.00014335296873468906,-0.0001501719088992104,-0.00015645487292204052,-0.00016221796977333724,-0.00016747775953263044,-0.0001722512097330764,-0.00017655554984230548,-0.0001804082130547613,-0.00018382679263595492,-0.00018682889640331268,-0.00018943210307043046,-0.00019165391859132797,-0.0001935116306412965,-0.00019502232316881418,-0.0001962027745321393,-0.00019706934108398855,-0.00019763804448302835,-0.00019792435341514647,-0.00019794327090494335,-0.00019770914514083415,-0.00019723584409803152,-0.00019653643539641052,-0.00019562343368306756,-0.00019450850959401578,-0.00019320272258482873,-0.00019171628809999675,-0.0001900586939882487,-0.0001882385549833998,-0.0001862638018792495,-0.00018414149235468358,-0.0001818778837332502,-0.00017947843298316002,-0.00017694786947686225,-0.0001742900349199772,-0.00017150805797427893,-0.0001686043688096106,-0.00016558055358473212,-0.00016243761638179421]'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: '[-0.00016243761638179421,-0.00016558055358473212,-0.0001686043688096106,-0.00017150805797427893,-0.0001742900349199772,-0.00017694786947686225,-0.00017947843298316002,-0.0001818778837332502,-0.00018414149235468358,-0.0001862638018792495,-0.0001882385549833998,-0.0001900586939882487,-0.00019171628809999675,-0.00019320272258482873,-0.00019450850959401578,-0.00019562343368306756,-0.00019653643539641052,-0.00019723584409803152,-0.00019770914514083415,-0.00019794327090494335,-0.00019792435341514647,-0.00019763804448302835,-0.00019706934108398855,-0.0001962027745321393,-0.00019502232316881418,-0.0001935116306412965,-0.00019165391859132797,-0.00018943210307043046,-0.00018682889640331268,-0.00018382679263595492,-0.0001804082130547613,-0.00017655554984230548,-0.0001722512097330764,-0.00016747775953263044,-0.00016221796977333724,-0.00015645487292204052,-0.0001501719088992104,-0.00014335296873468906,-0.00013598246732726693,-0.00012804550351575017,-0.00011952789645874873,-0.00011041626567021012,-0.0001006981692626141,-9.036214032676071e-05,-7.939784700283781e-05,-6.779612158425152e-05,-5.554909148486331e-05,-4.265023744665086e-05,-2.909450813604053e-05,-1.4878390174999367e-05,1.4229635233519693e-19,1.554083610244561e-05,3.174250741722062e-05,4.860152330365963e-05,6.611246499232948e-05,8.426790736848488e-05,0.00010305832984158769,0.0001224720908794552,0.00014249533705879003,0.0001631119812373072,0.0001843036152422428,0.00020604950259439647,0.0002283265203004703,0.00025110915885306895,0.00027436940581537783,0.00029807683313265443,0.0003221985243726522,0.0003466990601737052,0.00037154057645238936,0.00039668273529969156,0.00042208266677334905,0.0004476950562093407,0.0004734722606372088,0.0004993641632609069,0.0005253182607702911,0.0005512798670679331,0.0005771919386461377,0.0006029954529367387,0.0006286289426498115,0.0006540293106809258,0.0006791310734115541,0.0007038672920316458,0.0007281691650860012,0.0007519660866819322,0.0007751862285658717,0.0007977559580467641,0.0008196007693186402,0.0008406448177993298,0.0008608114439994097,0.0008800228242762387,0.0008982007275335491,0.0009152663988061249,0.000931140617467463,0.0009457439882680774,0.0009589973487891257,0.0009708214201964438,0.0009811373893171549,0.000989867141470313,0.0009969334350898862,0.0010022593196481466,0.0010057700565084815,0.0010073913726955652,0.0010070513235405087,0.0010046788956969976,0.001000206102617085,0.0009935664711520076,0.0009846960892900825,0.0009735338971950114,0.00096002162899822,0.0009441041038371623,0.0009257293422706425,0.0009048490319401026,0.0008814185275696218,0.0008553969673812389,0.0008267477969639003,0.0007954387692734599,0.000761442061048001,0.000724734622053802,0.0006852982915006578,0.000643119914457202,0.000598191749304533,0.0005505112349055707,0.0005000816308893263,0.0004469116684049368,0.0003910161030944437,0.00033241568598896265,0.0002711371926125139,0.00020721375767607242,0.0001406847295584157,7.159602682804689e-05,-4.542498005998868e-19,-7.404436473734677e-05,-0.00015047141641844064,-0.00022920880292076617,-0.0003101773909293115,-0.0003932913823518902,-0.0004784580087289214,-0.0005655778222717345,-0.000654544506687671,-0.0007452451973222196,-0.0008375601028092206,-0.000931362621486187,-0.0010265200398862362,-0.0011228928342461586,-0.0012203347869217396,-0.001318693975917995,-0.001417811494320631,-0.0015175234293565154,-0.0016176586505025625,-0.0017180412542074919,-0.0018184896325692534,-0.0019188161240890622,-0.002018829109147191,-0.002118330681696534,-0.002217118861153722,-0.002314987126737833,-0.0024117249995470047,-0.0025071173440665007,-0.0026009457651525736,-0.002692988608032465,-0.002783020492643118,-0.002870814176276326,-0.0029561391565948725,-0.003038763301447034,-0.003118452150374651,-0.0031949705444276333,-0.0032680814620107412,-0.003337548114359379,-0.003403132315725088,-0.003464596578851342,-0.0035217038821429014,-0.0035742181353271008,-0.0036219037137925625,-0.0036645270884037018,-0.0037018575239926577,-0.0037336654495447874,-0.0037597252521663904,-0.0037798138801008463,-0.0037937117740511894,-0.0038012047298252583,-0.003802082035690546,-0.0037961374036967754,-0.003783171297982335,-0.0037629888392984867,-0.0037354021333158016,-0.003700228873640299,-0.003657294437289238,-0.0036064311861991882,-0.0035474796313792467,-0.00348028726875782,-0.003404711140319705,-0.0033206166699528694,-0.0032278785947710276,-0.003126380732282996,-0.003016016911715269,-0.0028966909740120173,-0.0027683174703270197,-0.0026308209635317326,-0.0024841378908604383,-0.0023282149340957403,-0.002163011347874999,-0.0019884968642145395,-0.001804653787985444,-0.001611476531252265,-0.001408971264027059,-0.001197157078422606,-0.0009760655811987817,-0.0007457407773472369,-0.0005062395357526839,-0.0002576317056082189,8.1740881778420905e-19,0.0002665599749889225,0.0005419395165517926,0.0008260168833658099,0.0011186576448380947,0.0014197139535099268,0.0017290255054831505,0.0020464190747588873,0.0023717086296528578,0.002704695798456669,0.003045169170945883,0.003392905695363879,0.003747669979929924,0.004109214525669813,0.004477281589061022,0.004851599223911762,0.005231886636465788,0.0056178513914346695,0.00600919034332037,0.0064055901020765305,0.006806728430092335,0.00721227191388607,0.007621878292411566,0.008035196922719479,0.008451870642602444,0.008871530182659626,0.009293802082538605,0.009718302637338638,0.010144648142158985,0.010572440922260284,0.011001280508935452,0.011430763639509678,0.011860480532050133,0.012290016748011112,0.012718955054879189,0.01314687542617321,0.013573355972766876,0.013997972011566162,0.014420296996831894,0.014839903451502323,0.015256367623806,0.015669258311390877,0.016078155487775803,0.016482634469866753,0.016882270574569702,0.017276648432016373,0.017665350809693336,0.018047966063022614,0.01842408813536167,0.018793314695358276,0.019155248999595642,0.01950949989259243,0.019855687394738197,0.02019342966377735,0.02052236534655094,0.02084212936460972,0.021152373403310776,0.021452754735946655,0.021742939949035645,0.022022608667612076,0.022291451692581177,0.02254916913807392,0.02279547043144703,0.023030081763863564,0.023252742365002632,0.02346320077776909,0.023661216720938683,0.023846570402383804,0.02401905134320259,0.024178465828299522,0.024324631318449974,0.024457382038235664,0.024576568976044655,0.024682054296135902,0.024773718789219856,0.024851461872458458,0.024915188550949097,0.02496482990682125,0.025000328198075294,0.025021642446517944,0.02502875030040741,0.025021642446517944,0.025000328198075294,0.02496482990682125,0.024915188550949097,0.024851461872458458,0.024773718789219856,0.024682054296135902,0.024576568976044655,0.024457382038235664,0.024324631318449974,0.024178465828299522,0.02401905134320259,0.023846570402383804,0.023661216720938683,0.02346320077776909,0.023252742365002632,0.023030081763863564,0.02279547043144703,0.02254916913807392,0.022291451692581177,0.022022608667612076,0.021742939949035645,0.021452754735946655,0.021152373403310776,0.02084212936460972,0.02052236534655094,0.02019342966377735,0.019855687394738197,0.01950949989259243,0.019155248999595642,0.018793314695358276,0.01842408813536167,0.018047966063022614,0.017665350809693336,0.017276648432016373,0.016882270574569702,0.016482634469866753,0.016078155487775803,0.015669258311390877,0.015256367623806,0.014839903451502323,0.014420296996831894,0.013997972011566162,0.013573355972766876,0.01314687542617321,0.012718955054879189,0.012290016748011112,0.011860480532050133,0.011430763639509678,0.011001280508935452,0.010572440922260284,0.010144648142158985,0.009718302637338638,0.009293802082538605,0.008871530182659626,0.008451870642602444,0.008035196922719479,0.007621878292411566,0.00721227191388607,0.006806728430092335,0.0064055901020765305,0.00600919034332037,0.0056178513914346695,0.005231886636465788,0.004851599223911762,0.004477281589061022,0.004109214525669813,0.003747669979929924,0.003392905695363879,0.003045169170945883,0.002704695798456669,0.0023717086296528578,0.0020464190747588873,0.0017290255054831505,0.0014197139535099268,0.0011186576448380947,0.0008260168833658099,0.0005419395165517926,0.0002665599749889225,8.1740881778420905e-19,-0.0002576317056082189,-0.0005062395357526839,-0.0007457407773472369,-0.0009760655811987817,-0.001197157078422606,-0.001408971264027059,-0.001611476531252265,-0.001804653787985444,-0.0019884968642145395,-0.002163011347874999,-0.0023282149340957403,-0.0024841378908604383,-0.0026308209635317326,-0.0027683174703270197,-0.0028966909740120173,-0.003016016911715269,-0.003126380732282996,-0.0032278785947710276,-0.0033206166699528694,-0.003404711140319705,-0.00348028726875782,-0.0035474796313792467,-0.0036064311861991882,-0.003657294437289238,-0.003700228873640299,-0.0037354021333158016,-0.0037629888392984867,-0.003783171297982335,-0.0037961374036967754,-0.003802082035690546,-0.0038012047298252583,-0.0037937117740511894,-0.0037798138801008463,-0.0037597252521663904,-0.0037336654495447874,-0.0037018575239926577,-0.0036645270884037018,-0.0036219037137925625,-0.0035742181353271008,-0.0035217038821429014,-0.003464596578851342,-0.003403132315725088,-0.003337548114359379,-0.0032680814620107412,-0.0031949705444276333,-0.003118452150374651,-0.003038763301447034,-0.0029561391565948725,-0.002870814176276326,-0.002783020492643118,-0.002692988608032465,-0.0026009457651525736,-0.0025071173440665007,-0.0024117249995470047,-0.002314987126737833,-0.002217118861153722,-0.002118330681696534,-0.002018829109147191,-0.0019188161240890622,-0.0018184896325692534,-0.0017180412542074919,-0.0016176586505025625,-0.0015175234293565154,-0.001417811494320631,-0.001318693975917995,-0.0012203347869217396,-0.0011228928342461586,-0.0010265200398862362,-0.000931362621486187,-0.0008375601028092206,-0.0007452451973222196,-0.000654544506687671,-0.0005655778222717345,-0.0004784580087289214,-0.0003932913823518902,-0.0003101773909293115,-0.00022920880292076617,-0.00015047141641844064,-7.404436473734677e-05,-4.542498005998868e-19,7.159602682804689e-05,0.0001406847295584157,0.00020721375767607242,0.0002711371926125139,0.00033241568598896265,0.0003910161030944437,0.0004469116684049368,0.0005000816308893263,0.0005505112349055707,0.000598191749304533,0.000643119914457202,0.0006852982915006578,0.000724734622053802,0.000761442061048001,0.0007954387692734599,0.0008267477969639003,0.0008553969673812389,0.0008814185275696218,0.0009048490319401026,0.0009257293422706425,0.0009441041038371623,0.00096002162899822,0.0009735338971950114,0.0009846960892900825,0.0009935664711520076,0.001000206102617085,0.0010046788956969976,0.0010070513235405087,0.0010073913726955652,0.0010057700565084815,0.0010022593196481466,0.0009969334350898862,0.000989867141470313,0.0009811373893171549,0.0009708214201964438,0.0009589973487891257,0.0009457439882680774,0.000931140617467463,0.0009152663988061249,0.0008982007275335491,0.0008800228242762387,0.0008608114439994097,0.0008406448177993298,0.0008196007693186402,0.0007977559580467641,0.0007751862285658717,0.0007519660866819322,0.0007281691650860012,0.0007038672920316458,0.0006791310734115541,0.0006540293106809258,0.0006286289426498115,0.0006029954529367387,0.0005771919386461377,0.0005512798670679331,0.0005253182607702911,0.0004993641632609069,0.0004734722606372088,0.0004476950562093407,0.00042208266677334905,0.00039668273529969156,0.00037154057645238936,0.0003466990601737052,0.0003221985243726522,0.00029807683313265443,0.00027436940581537783,0.00025110915885306895,0.0002283265203004703,0.00020604950259439647,0.0001843036152422428,0.0001631119812373072,0.00014249533705879003,0.0001224720908794552,0.00010305832984158769,8.426790736848488e-05,6.611246499232948e-05,4.860152330365963e-05,3.174250741722062e-05,1.554083610244561e-05,1.4229635233519693e-19,-1.4878390174999367e-05,-2.909450813604053e-05,-4.265023744665086e-05,-5.554909148486331e-05,-6.779612158425152e-05,-7.939784700283781e-05,-9.036214032676071e-05,-0.0001006981692626141,-0.00011041626567021012,-0.00011952789645874873,-0.00012804550351575017,-0.00013598246732726693,-0.00014335296873468906,-0.0001501719088992104,-0.00015645487292204052,-0.00016221796977333724,-0.00016747775953263044,-0.0001722512097330764,-0.00017655554984230548,-0.0001804082130547613,-0.00018382679263595492,-0.00018682889640331268,-0.00018943210307043046,-0.00019165391859132797,-0.0001935116306412965,-0.00019502232316881418,-0.0001962027745321393,-0.00019706934108398855,-0.00019763804448302835,-0.00019792435341514647,-0.00019794327090494335,-0.00019770914514083415,-0.00019723584409803152,-0.00019653643539641052,-0.00019562343368306756,-0.00019450850959401578,-0.00019320272258482873,-0.00019171628809999675,-0.0001900586939882487,-0.0001882385549833998,-0.0001862638018792495,-0.00018414149235468358,-0.0001818778837332502,-0.00017947843298316002,-0.00017694786947686225,-0.0001742900349199772,-0.00017150805797427893,-0.0001686043688096106,-0.00016558055358473212,-0.00016243761638179421]'
    type: fff
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    bw0: 1e5
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color4: dark blue
    color5: dark red
    label1: Comp2Mag_noTh
    label2: Demod_noTh
    label3: Comp2Mag_Th
    label4: Demod_Th
    label5: Comp2Mag_Th_and_Demod_th_mult
    nconnections: '5'
    size: int(1e6)
    srate: samp_rate
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', interp_fir_filter_xxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_xx_0, '0', epy_block_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_threshold_ff_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_threshold_ff_0_0, '0', qtgui_time_sink_x_0, '3']
- [interp_fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [interp_fir_filter_xxx_0_0, '0', blocks_threshold_ff_0_0, '0']
- [interp_fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0, '1']
- [osmosdr_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
